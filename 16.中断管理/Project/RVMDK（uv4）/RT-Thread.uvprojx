# Keil uVision project RT-Thread.uvprojx, settings and files
target LED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RT-Thread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\startup;..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\RVMDK（uv4）;..\..\Bsp;..\..\RT-Thread\3.0.3\components\finsh;..\..\RT-Thread\3.0.3\include;..\..\RT-Thread\3.0.3\include\libc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f4xx.c
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c stm32f4xx_conf.h includes.h board.c rtconfig.h
  group BSP
    ../../Bsp/: bsp_led.c bsp_uart.c bsp_key.c bsp_nvic.c bsp_exti.c
  group RTT/SOURCE
    ../../RT-Thread/3.0.3/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group RTT/PORTS
    ../../RT-Thread/3.0.3/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
